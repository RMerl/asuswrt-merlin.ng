# SWRDKB-1359: [RDKM][3390] Add new meta-rdk-broadcom-wifi layer.
SRC_URI_remove = "file://SWRDKB-1013_ccsp-p-and-m_no_wifi_poll_sleep_increase.patch"
